## configs/sample.yaml
```yaml
# Config for the sample part of the application.

sample:
  database_schema: sample
```
